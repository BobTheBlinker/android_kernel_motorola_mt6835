## kernel-5.15/sound/soc/codecs/fs1589/Kconfig
```kconfig
config SND_SOC_FS158X
	tristate "FourSemi  speaker amplifier"
	depends on I2C
	help
	  Config of FourSemi speaker amplifier.
```
